## boards/shields/TranAdeptBLE/Kconfig.defconfig
```kconfig
if SHIELD_TRANADEPTBLE

config ZMK_KEYBOARD_NAME
    default "TranAdept BLE"

config SPI
	default y

endif
```
